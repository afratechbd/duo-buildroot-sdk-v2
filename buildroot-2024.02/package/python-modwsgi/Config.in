## buildroot-2024.02/package/python-modwsgi/Config.in
```kconfig
config BR2_PACKAGE_PYTHON_MODWSGI
	bool "python-modwsgi"
	help
	  Apache MODWSGI

	  https://pypi.python.org/pypi/mod_wsgi
```
